<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2.ADC_Collect_Transmit_VOFA_F103C8T6.ewp</path>
  </project>
  <batchBuild />
</workspace>
